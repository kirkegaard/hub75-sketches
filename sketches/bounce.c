#include "hub75.h"

#include <math.h>
#include <stddef.h>

/* Sine scroller. Each letter bounces on its own phase and leaves a
   short color trail, darkest ghost first and the hot letter on top.
   Change MESSAGE to scroll something else. Unknown characters are a gap. */

static const char MESSAGE[] = "HI MIKE    ";

/* 5x7 glyphs, bit 4 is the left pixel. */
static const uint8_t DIGIT[10][7] = {
    {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E}, /* 0 */
    {0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E}, /* 1 */
    {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F}, /* 2 */
    {0x1E, 0x01, 0x01, 0x0E, 0x01, 0x01, 0x1E}, /* 3 */
    {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02}, /* 4 */
    {0x1F, 0x10, 0x10, 0x1E, 0x01, 0x01, 0x1E}, /* 5 */
    {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E}, /* 6 */
    {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}, /* 7 */
    {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E}, /* 8 */
    {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C}, /* 9 */
};

static const uint8_t LETTER[26][7] = {
    {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}, /* A */
    {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E}, /* B */
    {0x0E, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0E}, /* C */
    {0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E}, /* D */
    {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F}, /* E */
    {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10}, /* F */
    {0x0E, 0x10, 0x10, 0x17, 0x11, 0x11, 0x0E}, /* G */
    {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}, /* H */
    {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x1F}, /* I */
    {0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C}, /* J */
    {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}, /* K */
    {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F}, /* L */
    {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11}, /* M */
    {0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11}, /* N */
    {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}, /* O */
    {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10}, /* P */
    {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D}, /* Q */
    {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11}, /* R */
    {0x0E, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x0E}, /* S */
    {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}, /* T */
    {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}, /* U */
    {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04}, /* V */
    {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A}, /* W */
    {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11}, /* X */
    {0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04}, /* Y */
    {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}, /* Z */
};

/* Dark ghost to the hot letter, in the order they are drawn. */
static const uint8_t TRAIL[][3] = {
    {0x22, 0x3e, 0x37}, {0x38, 0x67, 0x5b}, {0x58, 0xa7, 0x89},
    {0x97, 0xc8, 0xb5}, {0xff, 0xf4, 0xbf}, {0xff, 0xca, 0x53},
    {0xff, 0x89, 0x3b}, {0xe5, 0x27, 0x38},
};

static const int GLYPH_W = 5;
static const int GLYPH_H = 7;
static const int GAP = 1;

static uint16_t bg;

static const uint8_t *glyph(char c) {
  if (c >= 'a' && c <= 'z') {
    c = (char)(c - 'a' + 'A');
  }
  if (c >= 'A' && c <= 'Z') {
    return LETTER[c - 'A'];
  }
  if (c >= '0' && c <= '9') {
    return DIGIT[c - '0'];
  }
  return NULL;
}

static void blit(const uint8_t *rows, int x, int y, int scale, uint16_t c) {
  int row;
  int col;

  fill(c);
  noStroke();
  for (row = 0; row < GLYPH_H; row++) {
    uint8_t bits = rows[row];
    for (col = 0; col < GLYPH_W; col++) {
      if (bits & (uint8_t)(1u << (4 - col))) {
        rect(x + col * scale, y + row * scale, scale, scale);
      }
    }
  }
}

static int text_span(int scale) {
  return (int)(sizeof MESSAGE - 1) * (GLYPH_W * scale + GAP * scale);
}

static void draw_message(int origin, int scale, int amp) {
  int trail = (int)(sizeof TRAIL / sizeof TRAIL[0]);
  int pitch = (GLYPH_W + GAP) * scale;
  int mid = height / 2 - (GLYPH_H * scale) / 2;
  int i;

  for (i = 0; MESSAGE[i] != '\0'; i++) {
    const uint8_t *rows = glyph(MESSAGE[i]);
    int ix = origin + i * pitch;
    int j;

    if (!rows) {
      continue;
    }
    for (j = 0; j < trail; j++) {
      float t = (float)frameCount * 0.16f - (float)i * 0.55f + (float)j * 0.12f;
      int x = ix + (trail - 1 - j);
      int y = mid + (int)(sinf(t) * (float)amp) + j;
      if (x >= width || x + GLYPH_W * scale < 0 || y >= height ||
          y + GLYPH_H * scale < 0) {
        continue;
      }
      blit(rows, x, y, scale, color(TRAIL[j][0], TRAIL[j][1], TRAIL[j][2]));
    }
  }
}

void setup(void) { bg = color(0, 0, 0); }

void draw(void) {
  int scale = height >= 32 ? 2 : 1;
  int glyph = GLYPH_H * scale;
  int amp = (height - glyph) / 2 - (int)(sizeof TRAIL / sizeof TRAIL[0]) - 1;
  int span;
  int scroll;
  int origin;

  if (amp < 1) {
    amp = 1;
  }
  span = text_span(scale);
  if (span < 1) {
    span = 1;
  }
  scroll = (int)(frameCount % (unsigned)span);
  background(bg);
  for (origin = -scroll; origin < width; origin += span) {
    draw_message(origin, scale, amp);
  }
}
